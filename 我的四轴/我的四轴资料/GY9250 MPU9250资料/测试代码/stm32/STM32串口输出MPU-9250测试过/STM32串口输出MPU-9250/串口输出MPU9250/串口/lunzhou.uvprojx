# Keil uVision project lunzhou.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lunzhou +hex
  c flags: Optim=1
  c include: .\SRC;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SRC
    ./SRC/: main.c stm32f10x_it.c
  group LIB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_gpio.c stm32f10x_flash.c
  group STARTUP
    ./Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group CM3
    ./Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 4.3.0
