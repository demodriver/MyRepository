# Keil uVision project STM32F103V.uvprojx, settings and files
target STM32F103VC (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103V +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL,USE_STM3210E_EVAL
  c misc: --c99
  c include: ..\SRC\Startup;..\SRC\User;..\SRC\Fwlib\INC;..\SRC\Fwlib\SRC;..\OBJ;..\SRC\Driver\INC;..\SRC\Driver\SRC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../SRC/Startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s stm32_eval.c
  group USER
    ../SRC/User/: main.c stm32f10x_it.c
  group FWLIB
    ../SRC/Fwlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DRIVER
    ../SRC/Driver/SRC/: led.c delay.c tim.c usart.c sys.c spi.c inv_mpu.c inv_mpu_dmp_motion_driver.c motor.c mpu6050.c mpuiic.c ANO-Tech.c Kalman_filter.c PID.c
